# Keil uVision project BPG1101B-A.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HandPad_BPG1101B_20220222 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350,__TARGET_FPU_VFP
  c misc: --c99
  c include: ..\inc;..\src;..\..\Utilities;..\..\Firmware\CMSIS;..\..\Firmware\GD32F3x0_usbfs_driver\Include;..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\src\IQS;..\src\device
  library: MicroLIB
  memory RVCT4: ROM 0x8003800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../src/: adc.c app_usart.c comm.c config.c digitizer_comm.c gd32f3x0_it.c gpio.c hid_core.c hid_descriptor.c key.c led.c main.c pressure.c pwm.c queue.c scan.c system.c systick.c timer.c usart.c usb.c usb_delay.c wdog.c xy_antana.c xy_calibration.c
    ../src/IQS/: IQS.c ugee_i2c.c
  group cmsis
    ../../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_ctc.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_wwdgt.c gd32f3x0_tsi.c gd32f3x0_crc.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../../Firmware/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Lib
    ../lib/: digitizer_lib_200722.lib
  group Device
    ../src/device/: clock.c drv_pin.c serial.c taskschedule.c
    ../src/FlexibleButton/: flexible_button.c
  group RTT
    ../../RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
