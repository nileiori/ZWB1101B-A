# Keil uVision project BPG1101W_BootLoader.uvprojx, settings and files
target BPG1101W_Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BPG1010W_BootLoader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output .\Objects\BPG1101W_BootLoader.bin .\Objects\BPG1101W_BootLoader.axf
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c misc: --c99
  c include: ..\inc;..\src;..\Firmware\CMSIS;..\Firmware\GD32F3x0_usbfs_driver\Include;..\Firmware\GD32F3x0_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F3x0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: DFU.c Framework.c gd32f3x0_it.c hid_core.c main.c systick.c ugee_comm.c usb_delay.c
    ../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../Firmware/GD32F3x0_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group RTT
    ../RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
